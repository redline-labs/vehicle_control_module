# Repository redline-labs/vehicle_control_module (continued)

## EAGLE design hw/rev0/vehicle_control_module.brd (continued)

Schematic: vehicle_control_module.sch, sheet 15

Parts:
C148, C149, C150, C151, C152, C153, C154, C155: 0.01uF; C0603
D28, D29, D30, D31, D32, D33, D34, D35: BAT54SWFILMY; SOT65P210X110-3N
IC8: 74HC7541D-Q100J; SOIC127P1032X265-20N
R109, R118, R128, R138, R148, R158, R168, R178: 100k; R0603
R113, R123, R133, R143, R153, R163, R173, R198: 4.7k; R0603

Connections:
+3V3: D28.1 (A), D29.1 (A), D30.1 (A), D31.1 (A), D32.1 (A), D33.1 (A), D34.1 (A), D35.1 (A), IC8.20 (VCC); also elsewhere on the board
EXT_DINPUT_0: R198.1
EXT_DINPUT_1: R113.1
EXT_DINPUT_2: R123.1
EXT_DINPUT_3: R133.1
EXT_DINPUT_4: R143.1
EXT_DINPUT_5: R153.1
EXT_DINPUT_6: R163.1
EXT_DINPUT_7: R173.1
GND: C148.2, C149.2, C150.2, C151.2, C152.2, C153.2, C154.2, C155.2, D28.2 (K), D29.2 (K), D30.2 (K), D31.2 (K), D32.2 (K), D33.2 (K), D34.2 (K), D35.2 (K), IC8.1 (!OE1), IC8.10 (GND), IC8.19 (!OE2), R109.1, R118.1, R128.1, R138.1, R148.1, R158.1, R168.1, R178.1; also elsewhere on the board
unnamed: C148.1, D29.3 (A,K), IC8.3 (A1), R113.2, R118.2
unnamed: C149.1, D30.3 (A,K), IC8.4 (A2), R123.2, R128.2
unnamed: C150.1, D31.3 (A,K), IC8.5 (A3), R133.2, R138.2
unnamed: C151.1, D28.3 (A,K), IC8.2 (A0), R109.2, R198.2
unnamed: C152.1, D32.3 (A,K), IC8.6 (A4), R143.2, R148.2
unnamed: C153.1, D33.3 (A,K), IC8.7 (A5), R153.2, R158.2
unnamed: C154.1, D34.3 (A,K), IC8.8 (A6), R163.2, R168.2
unnamed: C155.1, D35.3 (A,K), IC8.9 (A7), R173.2, R178.2
PROT_DINPUT_0: IC8.18 (Y0); also elsewhere on the board
PROT_DINPUT_1: IC8.17 (Y1); also elsewhere on the board
PROT_DINPUT_2: IC8.16 (Y2); also elsewhere on the board
PROT_DINPUT_3: IC8.15 (Y3); also elsewhere on the board
PROT_DINPUT_4: IC8.14 (Y4); also elsewhere on the board
PROT_DINPUT_5: IC8.13 (Y5); also elsewhere on the board
PROT_DINPUT_6: IC8.12 (Y6); also elsewhere on the board
PROT_DINPUT_7: IC8.11 (Y7); also elsewhere on the board

Notes on the sheet:
14. Digital Input

Schematic: vehicle_control_module.sch, sheet 16

Parts:
C20, C21: 0.1uF; C0603
C22: 1000pF; C0603
J2: 2305018-2; TE_2305018-2
J3, J4, J5, J6, J7, J8, J9, J12: 1017505
J10: 5-2337992-3; 523379923
J11, J13: 2301843-1; 23018431
R26, R27, R28, R29: 75; R0603
R30, R33: 1k; R0603
R86, R87: 5.11k; R0603

Connections:
DEBUG_ETH_LED0: R30.1; also elsewhere on the board
DEBUG_ETH_LED1: R33.1; also elsewhere on the board
DEBUG_ETH_RXM: J10.P6; also elsewhere on the board
DEBUG_ETH_RXP: J10.P3; also elsewhere on the board
DEBUG_ETH_TXM: J10.P2; also elsewhere on the board
DEBUG_ETH_TXP: J10.P1; also elsewhere on the board
DEBUG_USB_DM: J2.A7 (DA_N), J2.B7 (DB_N); also elsewhere on the board
DEBUG_USB_DP: J2.A6 (DA_P), J2.B6 (DB_P); also elsewhere on the board
GND: C20.2, C21.2, C22.2, J2.A1 (GNDA), J2.A12 (GNDA), J2.B1 (GNDB), J2.B12 (GNDB), J2.G1 (GND), J2.G2 (GND), J2.S1 (SHIELD), J2.S2 (SHIELD), J2.S3 (SHIELD), J2.S4 (SHIELD), J10.MH1, J10.MH2, J10.P12 (CATHODE_GREEN), J10.P14 (CATHODE_YELLOW), J11.5, J11.MH1, J11.MH2, J13.5, J13.MH1, J13.MH2, R86.1, R87.1; also elsewhere on the board
unnamed: J10.P13 (ANODE_YELLOW), R33.2
unnamed: C20.1, J10.P4
unnamed: J10.P5, R26.2
unnamed: C21.1, J10.P7
unnamed: J10.P8, R27.2
unnamed: J10.P11 (ANODE_GREEN), R30.2
unnamed: J10.P10, R28.2
unnamed: J10.P9, R29.2
unnamed: C22.1, R26.1, R27.1, R28.1, R29.1
unnamed: J2.A5 (CC1), R86.2
unnamed: J2.B5 (CC2), R87.2
RS232_PORT0_RX: J11.2; also elsewhere on the board
RS232_PORT0_TX: J11.3; also elsewhere on the board
RS232_PORT1_RX: J13.2; also elsewhere on the board
RS232_PORT1_TX: J13.3; also elsewhere on the board

Notes on the sheet:
Power
Ethernet
CAN
Green LED = Serial Link is Up Yellow LED = Signal Detected
15. Connectors

Board: 2 copper layers, 496 parts (0 on the bottom side), 365 nets, no tracks yet.
